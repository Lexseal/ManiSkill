Commit message: refined init pose and upload test client

File: mani_skill/assets/robots/panda/panda_pizza.urdf (robot description, URDF)
Before this commit: robot panda, 10 links, 9 joints
Joints:
- joint pizza_peel_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0.2 0 0 rpy=-1.57 0 0
